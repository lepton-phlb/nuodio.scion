# IAR project nuodio_binaries_8.40.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: nuodio_binaries_7.30.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bin/nuodio
    ../../../../src/bin/nuodio/: adda.c boot.c tstboard.c tstusb.c
  group bin/nuodio/nu
    ../../../../src/bin/nuodio/nu/: nu.c nu.h
  group bin/nuodio/nu/displays
    ../../../../src/bin/nuodio/nu/displays/: nu_display_main.c nu_displays_definition.h
  group bin/nuodio/nu/displays/bitmaps
    ../../../../src/bin/nuodio/nu/displays/bitmaps/: gui.h label_0.c label_1.c label_2.c label_3.c label_4.c label_5.c label_6.c label_7.c label_8.c label_9.c label_bluetooth.c label_fuzz.c label_ge_tube.c label_germanium.c label_interface_full_fat.c label_interface_full_thin.c label_level.c label_sat.c label_si_tube.c label_silicium.c label_tone.c label_tube.c label_tube_ge.c label_tube_si.c
  group bin/nuodio/nuboot
    ../../../../src/bin/nuodio/nuboot/: nuboot.c nuboot.h
  group bin/nuodio/nuboot/displays/bitmaps
    ../../../../src/bin/nuodio/nuboot/displays/bitmaps/: gui.h label_bootloader_nb_icons_copy.c label_bootloader_nb_message_copy.c label_bootloader_nb_message_update.c label_bootloader_nb_progress_bar.c label_bootloader_nb_progress_element.c
