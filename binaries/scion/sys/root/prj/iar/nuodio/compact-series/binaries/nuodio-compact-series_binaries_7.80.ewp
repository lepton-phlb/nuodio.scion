# IAR project nuodio-compact-series_binaries_7.80.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; NDEBUG
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: nuodio-compact-series_binaries_7.80.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bin/nuodio/compact-series
    ../../../../../src/bin/nuodio/compact-series/: boot.c tstboard.c
  group bin/nuodio/compact-series/nu
    ../../../../../src/bin/nuodio/compact-series/nu/: nu.c nu.h nu_effect_parameters.c nu_effect_parameters.h
  group bin/nuodio/compact-series/nu/displays
    ../../../../../src/bin/nuodio/compact-series/nu/displays/: nu_display_main.c nu_displays_definition.h
  group bin/nuodio/compact-series/nu/displays/bitmaps
    ../../../../../src/bin/nuodio/compact-series/nu/displays/bitmaps/: gui.h label_nb_compact_0.c label_nb_compact_1.c label_nb_compact_2.c label_nb_compact_3.c label_nb_compact_4.c label_nb_compact_5.c label_nb_compact_6.c label_nb_compact_7.c label_nb_compact_8.c label_nb_compact_9.c label_nb_compact_bluetooth.c label_nb_compact_lookup.c label_nb_compact_midi.c label_nb_compact_moveto.c label_nb_compact_signed_m15_0_p15_0.c label_nb_compact_signed_m15_0_p15_m1.c label_nb_compact_signed_m15_0_p15_m10.c label_nb_compact_signed_m15_0_p15_m11.c label_nb_compact_signed_m15_0_p15_m12.c label_nb_compact_signed_m15_0_p15_m13.c label_nb_compact_signed_m15_0_p15_m14.c label_nb_compact_signed_m15_0_p15_m15.c label_nb_compact_signed_m15_0_p15_m2.c label_nb_compact_signed_m15_0_p15_m3.c label_nb_compact_signed_m15_0_p15_m4.c label_nb_compact_signed_m15_0_p15_m5.c label_nb_compact_signed_m15_0_p15_m6.c label_nb_compact_signed_m15_0_p15_m7.c label_nb_compact_signed_m15_0_p15_m8.c label_nb_compact_signed_m15_0_p15_m9.c label_nb_compact_signed_m15_0_p15_p1.c label_nb_compact_signed_m15_0_p15_p10.c label_nb_compact_signed_m15_0_p15_p11.c label_nb_compact_signed_m15_0_p15_p12.c label_nb_compact_signed_m15_0_p15_p13.c label_nb_compact_signed_m15_0_p15_p14.c label_nb_compact_signed_m15_0_p15_p15.c label_nb_compact_signed_m15_0_p15_p2.c label_nb_compact_signed_m15_0_p15_p3.c label_nb_compact_signed_m15_0_p15_p4.c label_nb_compact_signed_m15_0_p15_p5.c label_nb_compact_signed_m15_0_p15_p6.c label_nb_compact_signed_m15_0_p15_p7.c label_nb_compact_signed_m15_0_p15_p8.c label_nb_compact_signed_m15_0_p15_p9.c label_nb_compact_unsigned_0_15_0.c label_nb_compact_unsigned_0_15_1.c label_nb_compact_unsigned_0_15_10.c label_nb_compact_unsigned_0_15_11.c label_nb_compact_unsigned_0_15_12.c label_nb_compact_unsigned_0_15_13.c label_nb_compact_unsigned_0_15_14.c label_nb_compact_unsigned_0_15_15.c label_nb_compact_unsigned_0_15_2.c label_nb_compact_unsigned_0_15_3.c label_nb_compact_unsigned_0_15_4.c label_nb_compact_unsigned_0_15_5.c label_nb_compact_unsigned_0_15_6.c label_nb_compact_unsigned_0_15_7.c label_nb_compact_unsigned_0_15_8.c label_nb_compact_unsigned_0_15_9.c
  group bin/nuodio/compact-series/nu/parser
    ../../../../../src/bin/nuodio/compact-series/nu/parser/: numl_parser.c numl_parser.h
  group bin/nuodio/compact-series/nu/preset
    ../../../../../src/bin/nuodio/compact-series/nu/preset/: nu_preset.c nu_preset.h
  group bin/nuodio/midi
    ../../../../../src/bin/nuodio/midi/: midi_sysex.c midi_sysex.h midid.c
