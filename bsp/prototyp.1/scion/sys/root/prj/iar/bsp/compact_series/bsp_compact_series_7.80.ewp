# IAR project bsp_compact_series_7.80.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; USE_STDPERIPH_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc/legacy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bsp_compact_series_7.80.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/bsp/compact_series/dev_compact_series
    ../../../../src/kernel/dev/bsp/compact_series/dev_compact_series/: dev_ad5292.c dev_ad5292.h dev_compact_series_board_io.c dev_compact_series_board_io.h dev_compact_series_dac_1.c dev_compact_series_gpio.c dev_compact_series_gpio.h dev_compact_series_keybfootswitch.c dev_compact_series_oled_io.c dev_compact_series_rotary_encoder_1.c dev_compact_series_rotary_encoder_2.c dev_compact_series_rotary_encoder_3.c dev_compact_series_sdio.c dev_compact_series_spi_1.c dev_compact_series_spi_5.c dev_compact_series_spi_cs.c dev_compact_series_spi_cs.h dev_compact_series_uart_1.c dev_compact_series_uart_3.c dev_compact_series_uart_6.c dev_rotary_encoder_x.c dev_rotary_encoder_x.h ioctl_compact_series_gpio.h ioctl_rotary_encoder.h
