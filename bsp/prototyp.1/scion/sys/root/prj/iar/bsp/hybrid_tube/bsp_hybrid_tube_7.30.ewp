# IAR project bsp_hybrid_tube_7.30.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; USE_STDPERIPH_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc; c:/tauon/sys/root/src/kernel/dev/arch/cortexm\stm32f4xx/cubemx_hal_driver/inc/legacy
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bsp_hybrid_tube_7.30.srec
  ILINK.IlinkOutputFile: bsp_hybrid_tube_7.30.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group kernel/dev/bsp/hybrid_tube/cubemx_hal
    ../../../../src/kernel/dev/bsp/hybrid_tube/cubemx_hal/: gpio.c spi.c
  group kernel/dev/bsp/hybrid_tube/dev_hybrid_tube_board
    ../../../../src/kernel/dev/bsp/hybrid_tube/dev_hybrid_tube_board/: dev_hybrid_tube_board.c dev_hybrid_tube_board.h
  group kernel/dev/bsp/hybrid_tube/dev_hybrid_tube_peripherals
    ../../../../src/kernel/dev/bsp/hybrid_tube/dev_hybrid_tube_peripherals/: dev_hybrid_tube_oled_io.c dev_hybrid_tube_spi_5.c dev_hybrid_tube_spi_cs.c dev_hybrid_tube_spi_cs.h dev_hybrid_tube_uart_3.c dev_rotary_encoder_1.c dev_rotary_encoder_2.c dev_rotary_encoder_3.c dev_rotary_encoder_4.c dev_rotary_encoder_x.c dev_rotary_encoder_x.h ioctl_rotary_encoder.h
