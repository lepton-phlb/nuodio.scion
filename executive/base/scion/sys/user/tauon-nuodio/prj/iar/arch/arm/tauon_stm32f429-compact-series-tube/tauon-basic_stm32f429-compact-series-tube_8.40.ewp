# IAR project tauon-basic_stm32f429-compact-series-tube_8.40.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG=1; __VTOR_PRESENT
  ICCARM.CCIncludePath2: c:\tauon\sys\root\src\kernel\core\ucore\embOSCXM4_518\inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bret-interface-firmware-stm32f469il.hex
  ILINK.IlinkOutputFile: tauon-basic_stm32f4.out
  ILINK.IlinkIcfFile: C:\tauon\sys\user\tauon-nuodio\prj\iar\arch\arm\tauon_stm32f429-compact-series-tube\flash-nuodio-firmware.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LM3S9B96 TexasInstruments LM3S9B96
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCIncludePath2: ..\..\..\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: Start_LM3S9B96.out
configuration freertos-debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  ICCARM.CCDefines: OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG=1; ewarm; PART_LM3S9B96
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; C:\tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/DeviceSupport; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/core/ucore/cmsis; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkIcfFile: FLASH.icf
  group tauon/lib
    ../../../../../../../../building/output/bsp_compact_series_8.40/Debug/Lib/: bsp_compact_series_8.40.a
    ../../../../../../../../building/output/dev_stm32f4xx_8.40/Debug/Lib/: dev_stm32f4xx_8.40.a
    ../../../../../../../../building/output/nuodio-compact-series_binaries_8.40/Debug/Lib/: nuodio-compact-series_binaries_8.40.a
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_518/lib/: os7m_tl__sp.a
    ../../../../../../../../building/output/stm32f4_usb_core_8.40/Debug/Lib/: stm32f4_usb_core_8.40.a
    ../../../../../../../../building/output/tauon_8.40/tauon-kernel-cortex-m4-debug/Lib/: tauon_8.40.a
    ../../../../../../../../building/output/xgui_8.40/Debug/Lib/: xgui_8.40.a
  group tauon/sys/root/kernel/core/arch/arm
    ../../../../../../../root/src/kernel/core/arch/arm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/arch/cortexm
    ../../../../../../../root/src/kernel/core/arch/cortexm/: bin_mkconf.c dev_dskimg.c dev_dskimg.h dev_mkconf.c kernel_mkconf.h
  group tauon/sys/root/kernel/core/ucore/cmsis/core
    ../../../../../../../root/src/kernel/core/ucore/cmsis/CMSIS/Include/: arm_common_tables.h arm_math.h core_cm0.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/lm3s
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/lm3s/: lm3s_cmsis.h startup_ewarm.c system_lm3s.c system_lm3s.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f2xx
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f2xx/: stm32f2xx.h system_stm32f2xx.c system_stm32f2xx.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f2xx/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f2xx/startup/iar/: startup_stm32f2xx.s
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f4xx
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group tauon/sys/root/kernel/core/ucore/cmsis/device/st/stm32f4xx/startup
    ../../../../../../../root/src/kernel/core/ucore/cmsis/Device/st/stm32f4xx/startup/iar/: startup_stm32f4xx.s
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_386/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_386/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_386/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_CMSIS.c RTOSInit_STM32F4x_CMSIS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_440/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_440/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_440/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_440/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c RTOSInit_STM32F4x_CMSIS.c SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c xmtx.c xmtx2.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_518/arch/cmsis
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_518/arch/cmsis/: main.c
  group tauon/sys/root/kernel/core/ucore/embOSCXM4_518/arch/cmsis/cpu
    ../../../../../../../root/src/kernel/core/ucore/embOSCXM4_518/arch/cmsis/cpu/: JLINKMEM_Process.c OS_Error.c OS_ThreadSafe.c RTOSInit_STM32F4xx.c SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/cortex-m4/stm32f4/: main.c
  group tauon/sys/root/kernel/core/ucore/freeRTOS_8-0-0/arch/cortex-m4/stm32f4
    ../../../../../../../root/src/kernel/core/ucore/freeRTOS_8-0-0/source/arch/cortex-m4/stm32f4/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
