<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\bsp\compact_series\bsp_compact_series_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\bsp\hybrid_tube\bsp_hybrid_tube_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\dev\stm32f4xx\dev_stm32f4xx_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\nuodio\compact-series\binaries\nuodio-compact-series_binaries_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\stm32f4-usb-core\stm32f4_usb_core_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\tauon-basic_stm32f429-compact-series-tube_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\tauon\tauon_8.40.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\..\..\root\prj\iar\arch\arm\xgui\xgui_8.40.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all debug</name>
            <member>
                <project>bsp_compact_series_8.40</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dev_stm32f4xx_8.40</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>nuodio-compact-series_binaries_8.40</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>stm32f4_usb_core_8.40</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>xgui_8.40</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tauon_8.40</project>
                <configuration>tauon-kernel-cortex-m4-debug</configuration>
            </member>
            <member>
                <project>tauon-basic_stm32f429-compact-series-tube_8.40</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>all freertos debug</name>
            <member>
                <project>dev_stm32f4xx_7.20</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tauon_7.20</project>
                <configuration>tauon-kernel-cortex-m4f-freertos-debug</configuration>
            </member>
            <member>
                <project>tauon-basic_stm32f4_7.20</project>
                <configuration>freertos-debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>all bootloader</name>
            <member>
                <project>bsp_compact_series_7.80</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>dev_stm32f4xx_7.20</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>stm32f4_usb_core</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tauon_7.80</project>
                <configuration>tauon-kernel-cortex-m4-debug</configuration>
            </member>
            <member>
                <project>xgui</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>nuodio-compact-series_binaries_7.80</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>tauon-basic_stm32f429-compact-series-tube_7.80</project>
                <configuration>bootloader</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
